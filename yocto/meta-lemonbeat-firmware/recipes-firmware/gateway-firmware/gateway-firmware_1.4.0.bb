SUMMARY = "Empty dummy package: Lemonbeat gateway firmware for the radio module"
LICENSE = "CLOSED"

inherit systemd allarch
